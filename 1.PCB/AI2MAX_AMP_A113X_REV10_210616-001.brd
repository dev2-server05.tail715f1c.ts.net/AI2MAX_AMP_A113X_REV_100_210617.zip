# Allegro board AI2MAX_AMP_A113X_REV10_210616-001.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
N21727332 on TOP: 94.2,5.1 94.2,1.9 99.45,1.9 102.3,4.75 102.3,11.65 100,13.95 98.65,13.95 97.9,13.2 97.9,11.4 98.5,10.8 98.5,6.2 97.4,5.1

Small or netless copper shapes (teardrops, artwork): 1 on BOTTOM, 1 on MID1(L2), 1 on MID2(L3)

## Text on the board
BOTTOM: BOTTOM
Board Geometry/Soldermask Bottom: BOTTOM_SOLDERMASK
Ref Des/Silkscreen Bottom: NC | TD1 | TEN | TD0 | RD0 | RD1 | RCK | RDV | MIO | MDC | GND | VDD | VCC 3.3V | SPI_CLK | SPI_MOSI | SPI_MISO | SPI_SS | BL_EN | BL_PWM | LINE_OUT | RESET | I2C_SCK | I2C_SDA | AMP_RES | VDD 3.3V | AMP_DATA | AMP_BCLK | AMP_WCK | AMP_SCL | AMP_SDA | BOTTOM_SILKSCREEN
User.Comments: CR_UNNAMED_2 | 12.PCB Outline Dimension Tol: | 10.MATERIAL : | 11.PLATING : | 1. PCB VENDOR MUST BE UL  QUALIFIED | 2. BOARD MUST BE IDENTIFIED WITH APPROPRIATE VENDOR UL IDENTIFACTION MARK,DATE CODE | 3. PCB MATERIAL UL FLAMMIBILITY RATING(94V-0 MINIMUM) | 4. ALL DIMESION TOLERANCE AS BELOW UNLESS OTHERWISE SPECIFIED. | 5. PCB LAYERS : | 6. PCB THICKNESS : | 7. | 8. TOP SIDE SILKSCREEN : | 9. SOLDER MASK : | NOTES: | TRACE WIDTHS TO BE FINISHED SIZES+/-1MIL | BOTTOM SIDE SILKSCREEN: | 0.7mil(min) | Prepreg | Copper | Core | OSP 0.2-0.6um[8-24uinch]) | Top(L1) | Mid2(L3) | Bot(L4) | Mid1(L2) | FR4 | 4 LAYERs | GREEN | 1.6 mm+/-0.15 mm | TG: | ,BOTH SIDES | WHITE | 150 | 0.038 mm (H/1oz Finished) | 0.08 mm | 0.03 mm (1oz) | 1.274 mm | 0.015 mm | ROUTING : | CELSIUS | +/- 0.13mm | 1.6+/-0.15mm
TOP: TOP
Board Geometry/Soldermask Top: TOP_SOLDERMASK
Ref Des/Silkscreen Top: Label | 1 | 4 | AI2MAX AMP A113X REV1.0 | TOP_SILKSCREEN
MID1(L2): MID1(L2)
MID2(L3): MID2(L3)
PAGE_OUTLINE: Scale 1000mil | Layer name | PCB P/N | Rev. | Foxconn/CNSBG | 308.03524 | 015
DIMENSION: Prepreg | Copper | Core | Top(L1) | Mid2(L3) | Bot(L4) | Mid1(L2) | 0.038 mm (H/1oz Finished) | 0.08 mm | 0.03 mm (1oz) | 1.274 mm | 0.015 mm | 1.6+/-0.15mm | F
PLACE_BOUND_BOTTOM: 1 | Bottom Side Reflow | 0 degree | Top Side Reflow | 180 degree | Cavity_Number | *Reference CNSBG Break-Away rule | Unit:MM
User.15: MID3(L4)
User.16: MID4(L5)
User.17: MID5(L6)
User.18: MID6(L7)
User.19: MID7(L8)
User.20: MID8(L9)
User.21: MID9(L10)
User.22: MID11(L12)
User.23: MID12(L13)
User.26: BOTTOM_PASTE
User.27: TOP_PASTE
User.30: NCDRILL
User.32: BOTTOM_ASSEMBLY
User.33: TOP_ASSEMBLY
User.34: BOTTOM_ASSEMBLY
User.43: FIGURE | SIZE | 0.2 | 0.25 | 0.254 | 0.4064 | 1.0 | 1.1 | 1.8001 | 4.2 | 0.5 | 0.6 | 2.5 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILLIMETERS | TOLERANCE | +0.0762/-0.0762 | +0.0/-0.0 | PLATED | NON-PLATED | QTY | 429 | 1255 | 9 | 2 | 8 | 4 | 60 | 24
